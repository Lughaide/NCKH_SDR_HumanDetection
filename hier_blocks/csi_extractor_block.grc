options:
  parameters:
    author: rook
    generate_options: hb
    id: csi_extractor_block
    output_language: python
    title: Extracting CSI Data from CE
  states: {}

blocks:
- name: channel_estimation_source
  id: pad_source
  parameters:
    label: in
    type: complex
    vlen: '64'
  states: {}
- name: channel_state_data
  id: pad_sink
  parameters:
    label: out
    type: float
    vlen: '64'
  states: {}
- name: csi_extractor_script
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vector_size=64, num_subcarrier=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='CSI Information Extractor',   # will show up in GRC
                  in_sig=[(np.complex64, vector_size)],
                  out_sig=[(np.float32, vector_size), np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.num_subcarrier = num_subcarrier

          def work(self, input_items, output_items):
              tagTuple = self.get_tags_in_window(0, 0, len(input_items[0]))
              for tag in tagTuple:
                  if (pmt.to_python(tag.key) == 'ofdm_sync_chan_taps'):
                      temp = pmt.to_python(tag.value)
                      magnitude = abs(temp)
                      output_items[0][:] = magnitude
                      output_items[1][:] = magnitude[self.num_subcarrier]

              return len(output_items[0])
    num_subcarrier: num_subcarrier
    vector_size: vector_size
  states: {}
- name: csi_single_carrier
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: float
  states: {}
- name: import_pmt
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: num_subcarrier
  id: parameter
  parameters:
    label: Selected single subcarrier
    value: '10'
  states: {}
- name: vector_size
  id: parameter
  parameters:
    label: Vector Size for input
    value: '64'
  states: {}

connections:
- [channel_estimation_source, '0', csi_extractor_script, '0']
- [csi_extractor_script, '0', channel_state_data, '0']
- [csi_extractor_script, '1', csi_single_carrier, '0']

metadata:
  file_format: 1
